// =============================================================================
//  ecran_demarrage.h : écran de démarrage animé (64 × 128, portrait)
// =============================================================================
//  L'œil-thermomètre « ALL YOUR TANK ARE BELONG TO US », animé pendant la
//  connexion :
//    1. l'œil s'ouvre ;
//    2. les 5 rayons s'allument un par un ;
//    3. le texte s'écrit lettre par lettre (machine à écrire) ;
//    4. ensuite l'œil cligne de temps en temps.
//  En bas, en petit, un message (« WIFI... », « ADAFRUIT... », « CONNECTE ! »).
//
//  Tout est dessiné à partir d'UNE seule image (logo_oeil_bits) : à chaque
//  image de l'animation, on n'en recopie que des morceaux (l'œil plus ou moins
//  ouvert, les rayons déjà allumés, les lettres déjà écrites). Pour changer de
//  logo, remplacez l'image et ajustez les repères ci-dessous
//  (voir docs/personnaliser.md).
//
//  Image : licence CC BY-SA 4.0 (voir LICENSE-DOCS.md). Code : licence MIT.
// =============================================================================
#pragma once
#include <U8g2lib.h>

#define LOGO_OEIL_LARGEUR 64
#define LOGO_OEIL_HAUTEUR 128

// Image 1-bit au format XBM (1 = pixel allumé), 8 octets par ligne
static const unsigned char logo_oeil_bits[] PROGMEM = {
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x80, 0x01, 0x60, 0x00, 0x00, 0x00, 0x00, 0x06, 0x80, 0x01, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x0c, 0x80, 0x01, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0c, 0x80, 0x01, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x00, 0x00, 0x00, 0x18, 0x80, 0x01, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x80, 0x01, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0c, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x0c, 0x00, 0x01, 0xc0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0xc0, 0x01, 0x00, 0x0f, 0x00, 0x00, 0x00, 0x00, 0xf0, 0x00,
  0x00, 0x1c, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1c, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xfe, 0x7f, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xc0, 0xff, 0xff, 0x03, 0x00, 0x00, 0x00, 0x00, 0xf0, 0x01, 0x80, 0x0f, 0x00, 0x00,
  0x00, 0x00, 0x3c, 0x00, 0x00, 0x3c, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xa0, 0x05, 0xf0, 0x00, 0x00,
  0x00, 0x80, 0x03, 0x58, 0x1a, 0xc0, 0x01, 0x00, 0x00, 0xe0, 0x00, 0x64, 0x26, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x53, 0xca, 0x00, 0x0e, 0x00, 0x00, 0x18, 0x00, 0x69, 0x96, 0x00, 0x18, 0x00,
  0x00, 0x0c, 0x80, 0x54, 0x2a, 0x01, 0x30, 0x00, 0x00, 0x06, 0x40, 0x6a, 0x56, 0x02, 0x60, 0x00,
  0x80, 0x03, 0x40, 0x55, 0xaa, 0x02, 0xc0, 0x01, 0xc0, 0x01, 0xa0, 0x6a, 0x56, 0x05, 0x80, 0x03,
  0xe0, 0x00, 0x20, 0x55, 0xaa, 0x04, 0x00, 0x07, 0x60, 0x00, 0xa0, 0x6a, 0x56, 0x05, 0x00, 0x06,
  0x30, 0x00, 0x20, 0x55, 0xaa, 0x04, 0x00, 0x0c, 0xe0, 0x00, 0xa0, 0x6a, 0x56, 0x05, 0x00, 0x07,
  0xc0, 0x01, 0x20, 0x75, 0xae, 0x04, 0x80, 0x03, 0x80, 0x03, 0xa0, 0x7a, 0x5e, 0x05, 0xc0, 0x01,
  0x00, 0x06, 0x40, 0x35, 0xac, 0x02, 0x60, 0x00, 0x00, 0x0c, 0x40, 0x3a, 0x5c, 0x02, 0x30, 0x00,
  0x00, 0x18, 0x80, 0x74, 0x2e, 0x01, 0x18, 0x00, 0x00, 0x70, 0x00, 0xe9, 0x97, 0x00, 0x0e, 0x00,
  0x00, 0xe0, 0x00, 0xd3, 0xcb, 0x00, 0x07, 0x00, 0x00, 0x80, 0x03, 0xa4, 0x25, 0xc0, 0x01, 0x00,
  0x00, 0x00, 0x0f, 0x18, 0x18, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x3c, 0xe0, 0x07, 0x3c, 0x00, 0x00,
  0x00, 0x00, 0xf0, 0x01, 0x80, 0x0f, 0x00, 0x00, 0x00, 0x00, 0xc0, 0xff, 0xff, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xfe, 0x7f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x89, 0x40, 0x5d, 0x0d, 0x4e, 0x52, 0x01, 0x80, 0x8a, 0x40, 0x55, 0x15, 0xa4, 0x56, 0x01,
  0x80, 0x8b, 0x80, 0x54, 0x0d, 0xe4, 0xda, 0x00, 0x80, 0x8a, 0x80, 0x54, 0x15, 0xa4, 0x52, 0x01,
  0x80, 0xba, 0x83, 0xdc, 0x15, 0xa4, 0x52, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x73, 0x98, 0x8b, 0x4b, 0x06, 0x00, 0x00, 0x50, 0x15, 0xa8, 0x88, 0x5a, 0x01, 0x00,
  0x00, 0x70, 0x33, 0x98, 0x89, 0x6a, 0x05, 0x00, 0x00, 0x50, 0x15, 0xa8, 0x88, 0x4a, 0x05, 0x00,
  0x00, 0x50, 0x75, 0x98, 0xbb, 0x4b, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x3b, 0x94, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x29, 0x54, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x29, 0x94, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x29, 0x14, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x39, 0xdc, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};

// ---------------------------------------------------------------- repères
// Œil : lignes 39 à 68, centre entre les lignes 53 et 54
const int OEIL_HAUT = 39, OEIL_BAS = 68;
const float OEIL_CENTRE = 53.5f;

// Les 5 rayons, dans l'ordre d'allumage : x0, y0, x1, y1 (x1 et y1 exclus)
const uint8_t RAYONS[5][4] = {
  {31, 22, 33, 31},   // celui du milieu
  {17, 24, 23, 33},   // à gauche
  {41, 24, 47, 33},   // à droite
  { 6, 32, 13, 39},   // tout à gauche
  {51, 32, 58, 39},   // tout à droite
};

// Texte : haut de chaque ligne (5 pixels de haut), puis pour chaque lettre
// (espaces compris) sa ligne et son bord droit
const uint8_t TEXTE_Y[3] = {92, 100, 108};
const uint8_t NB_LETTRES = 28;
const uint8_t LETTRE_LIGNE[NB_LETTRES] = {0,0,0,0,0,0,0,0,0,0,0,0,0, 1,1,1,1,1,1,1,1,1,1, 2,2,2,2,2};
const uint8_t LETTRE_FIN[NB_LETTRES] = {10,14,18,21,25,29,33,37,40,44,48,53,57,
                                        15,19,23,26,30,34,38,42,47,51, 26,30,33,37,41};

// ---------------------------------------------------------------- minutage (ms)
const unsigned long DUREE_OUVERTURE = 640;   // l'œil s'ouvre
const unsigned long DEBUT_RAYONS = 720;
const unsigned long PAS_RAYON = 160;         // un rayon de plus toutes les 160 ms
const unsigned long DEBUT_TEXTE = 1600;
const unsigned long PAS_LETTRE = 80;         // une lettre toutes les 80 ms
const unsigned long FIN_INTRO = DEBUT_TEXTE + NB_LETTRES * PAS_LETTRE + 60;
const unsigned long DEBUT_CLIGNEMENTS = FIN_INTRO + 900;
const unsigned long PERIODE_CLIGNEMENT = 2400;

// Un pixel de l'image est-il allumé ?
static bool pixelLogo(int x, int y) {
  return (pgm_read_byte(&logo_oeil_bits[y * (LOGO_OEIL_LARGEUR / 8) + x / 8]) >> (x % 8)) & 1;
}

// Recopie à l'écran le rectangle [x0, x1[ × [y0, y1[ de l'image. Avec un
// décalage, chaque ligne est prise « décalage » lignes plus bas dans l'image.
static void copierLogo(U8G2 &e, int x0, int y0, int x1, int y1, int decalage = 0) {
  for (int y = y0; y < y1; y++) {
    int ys = y + decalage;
    if (ys < 0 || ys >= LOGO_OEIL_HAUTEUR) continue;
    for (int x = x0; x < x1; x++) {
      if (pixelLogo(x, ys)) e.drawPixel(x, y);
    }
  }
}

// L'œil ouvert à la proportion f (1 = grand ouvert, 0 = fermé) :
// chaque ligne affichée est prise plus loin du centre dans l'image.
static void dessinerOeil(U8G2 &e, float f) {
  if (f < 0.05f) {                       // fermé : un simple trait
    e.drawHLine(5, 53, 54);
    e.drawHLine(5, 54, 54);
    return;
  }
  for (int y = OEIL_HAUT; y <= OEIL_BAS; y++) {
    int source = (int)lroundf(OEIL_CENTRE + (y - OEIL_CENTRE) / f);
    if (source < OEIL_HAUT || source > OEIL_BAS) continue;
    copierLogo(e, 0, y, LOGO_OEIL_LARGEUR, y + 1, source - y);
  }
}

// Ouverture de l'œil selon le temps : ouverture au début, puis clignements
static float ouvertureOeil(unsigned long t) {
  if (t < DUREE_OUVERTURE) return (float)t / DUREE_OUVERTURE;
  if (t < DEBUT_CLIGNEMENTS) return 1.0f;
  unsigned long phase = (t - DEBUT_CLIGNEMENTS) % PERIODE_CLIGNEMENT;
  const float clignement[6] = {1.0f, 0.6f, 0.2f, 0.0f, 0.2f, 0.6f};   // 80 ms chacun
  return phase < 6 * 80 ? clignement[phase / 80] : 1.0f;
}

// Dessine l'écran de démarrage au temps t (ms depuis le début) avec le message
// en bas. Renvoie true quand l'animation d'ouverture est finie (texte complet).
static bool dessinerDemarrage(U8G2 &e, unsigned long t, const char *message) {
  e.clearBuffer();

  dessinerOeil(e, ouvertureOeil(t));

  // Rayons
  int nbRayons = t < DEBUT_RAYONS ? 0 : (t - DEBUT_RAYONS) / PAS_RAYON + 1;
  if (nbRayons > 5) nbRayons = 5;
  for (int i = 0; i < nbRayons; i++) {
    copierLogo(e, RAYONS[i][0], RAYONS[i][1], RAYONS[i][2], RAYONS[i][3]);
  }

  // Texte, lettre par lettre : on dévoile chaque ligne jusqu'à la dernière lettre écrite
  int nbLettres = t < DEBUT_TEXTE ? 0 : (t - DEBUT_TEXTE) / PAS_LETTRE;
  if (nbLettres > NB_LETTRES) nbLettres = NB_LETTRES;
  for (int ligne = 0; ligne < 3; ligne++) {
    int fin = 0;
    for (int k = 0; k < nbLettres; k++) {
      if (LETTRE_LIGNE[k] == ligne) fin = LETTRE_FIN[k];
    }
    if (fin > 0) copierLogo(e, 0, TEXTE_Y[ligne], fin, TEXTE_Y[ligne] + 5);
  }

  // Message de connexion, centré tout en bas
  e.setFont(u8g2_font_tom_thumb_4x6_tr);
  e.drawStr((LOGO_OEIL_LARGEUR - e.getStrWidth(message)) / 2, 126, message);

  e.sendBuffer();
  return t >= FIN_INTRO;
}
